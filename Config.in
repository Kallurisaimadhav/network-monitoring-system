## Config.in
```kconfig
config BR2_PACKAGE_NETWORK_MONITOR
	bool "Network Monitor"
	help
	  Embedded Network Monitoring System using Buildroor.
```
